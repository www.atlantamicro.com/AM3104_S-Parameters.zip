!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -18.23 dB at 4.208 GHz (marker M1); lowest = -75.4 dB at 14.29 GHz (marker M2)
!   lowest |S11| = -15.2 dB at 3.983 GHz (marker M3), VSWR 1.42, Z = 36.2 + j5.92 ohm
!   |S11| at or under -10 dB: 3.352 GHz to 4.257 GHz (904.9 MHz wide, 23.8 % of centre)
!   |S22| runs from -22.3 to 13.6 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.858 GHz to 4.233 GHz only
!   S11 on the Smith chart (normalised r, x): 3.858 GHz: 0.85, +0.40; 3.946 GHz: 0.80, -0.25; 4.045 GHz: 1.46, +0.06; 4.12 GHz: 0.61, -0.02; 4.183 GHz: 1.57, +0.46; 4.233 GHz: 0.75, -0.50
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -53.7  -53.4  -0.1
! 1.597 GHz  -2.4  -38.9  -40.4  0.9
! 3.021 GHz  -5.8  -65.0  -64.3  -1.0
! 3.346 GHz  -9.9  -56.6  -57.0  -1.5
! 3.858 GHz  -13.0  -41.2  -41.1  -4.1
! 3.946 GHz  -14.9  -31.8  -31.7  -6.0
! 3.983 GHz  -15.2  -28.0  -28.0  -7.2
! 4.045 GHz  -14.5  -23.1  -23.1  -9.7
! 4.12 GHz  -12.4  -19.6  -19.6  -12.4
! 4.183 GHz  -11.1  -18.3  -18.4  -14.7
! 4.208 GHz  -10.6  -18.2  -18.3  -15.5
! 4.233 GHz  -10.3  -18.3  -18.4  -16.0
! 5.695 GHz  -3.1  -67.9  -70.8  -3.0
! 6.682 GHz  -1.2  -50.6  -50.7  -6.4
! 10.01 GHz  -2.6  -47.3  -47.4  -4.4
! 11.3 GHz  -2.8  -37.8  -38.1  -4.9
! 13.34 GHz  -2.0  -48.0  -48.1  -3.5
! 14.29 GHz  -1.4  -75.4  -70.9  -2.7
! 16.68 GHz  -1.6  -59.2  -60.9  7.2
! 17.69 GHz  -1.6  -65.3  -68.0  -3.7
! 18.58 GHz  -0.9  -41.6  -41.9  -21.9
! 20 GHz  -1.4  -33.5  -33.3  -2.5
