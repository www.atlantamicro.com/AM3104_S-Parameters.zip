!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -32.52 dB at 4.145 GHz (marker M1); lowest = -76.8 dB at 13.95 GHz (marker M2)
!   lowest |S11| = -13.3 dB at 3.746 GHz (marker M3), VSWR 1.55, Z = 75.8 + j9.01 ohm
!   |S11| at or under -10 dB: 3.044 GHz to 4.033 GHz (989.5 MHz wide, 28 % of centre)
!   |S22| runs from -24.3 to 13.7 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.658 GHz to 3.846 GHz only
!   S11 on the Smith chart (normalised r, x): 3.658 GHz: 0.74, -0.35; 3.733 GHz: 1.26, +0.42; 3.783 GHz: 0.97, -0.45; 3.821 GHz: 0.62, -0.02; 3.846 GHz: 0.73, +0.33
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -50.3  -54.7  0.0
! 1.734 GHz  -4.8  -39.5  -39.6  -0.6
! 2.996 GHz  -9.0  -63.2  -62.9  -1.0
! 3.346 GHz  -11.4  -55.8  -55.5  -1.5
! 3.658 GHz  -12.3  -58.2  -59.4  -2.4
! 3.733 GHz  -13.3  -57.1  -57.9  -2.9
! 3.746 GHz  -13.3  -56.9  -57.3  -2.9
! 3.783 GHz  -13.1  -55.4  -55.7  -3.3
! 3.821 GHz  -12.7  -52.7  -52.6  -3.6
! 3.846 GHz  -12.4  -50.8  -50.6  -3.9
! 4.145 GHz  -9.6  -32.5  -32.6  -14.8
! 4.87 GHz  -4.5  -71.5  -69.6  -8.1
! 6.682 GHz  -0.9  -48.7  -48.6  -5.7
! 10.01 GHz  -2.6  -48.1  -47.9  -4.6
! 11.14 GHz  -2.7  -40.9  -41.0  -4.4
! 13.34 GHz  -1.9  -55.8  -55.2  -3.3
! 13.95 GHz  -0.9  -76.8  -73.6  -2.5
! 16.68 GHz  -1.5  -60.8  -62.1  7.2
! 17.69 GHz  -1.5  -68.8  -66.6  -3.8
! 18.55 GHz  -0.9  -41.9  -41.9  -24.3
! 19 GHz  -1.2  -38.5  -38.6  -6.3
! 20 GHz  -1.4  -33.9  -33.6  -2.5
