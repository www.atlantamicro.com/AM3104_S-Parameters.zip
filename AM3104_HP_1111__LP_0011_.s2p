!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -21.25 dB at 4.183 GHz (marker M1); lowest = -72.6 dB at 13.77 GHz (marker M2)
!   lowest |S11| = -14.7 dB at 3.921 GHz (marker M3), VSWR 1.45, Z = 58.2 - j18.5 ohm
!   |S11| at or under -10 dB: 3.291 GHz to 4.162 GHz (871.9 MHz wide, 23.4 % of centre)
!   |S22| runs from -23.8 to 13.7 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.821 GHz to 4.108 GHz only
!   S11 on the Smith chart (normalised r, x): 3.821 GHz: 0.64, -0.05; 3.883 GHz: 1.33, +0.29; 4.07 GHz: 1.13, -0.57; 4.108 GHz: 0.56, -0.12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -49.1  -55.6  -0.1
! 1.747 GHz  -4.0  -39.2  -39.2  -0.6
! 3.009 GHz  -6.1  -63.5  -64.0  -1.0
! 3.346 GHz  -11.0  -56.1  -55.9  -1.5
! 3.821 GHz  -13.1  -45.6  -45.6  -3.6
! 3.883 GHz  -14.5  -39.5  -39.6  -4.5
! 3.921 GHz  -14.7  -35.7  -35.8  -5.3
! 4.07 GHz  -11.6  -23.8  -23.8  -10.5
! 4.108 GHz  -10.7  -22.4  -22.5  -12.1
! 4.183 GHz  -9.8  -21.3  -21.3  -15.4
! 5.22 GHz  -4.3  -65.8  -66.9  -4.4
! 5.795 GHz  -2.4  -71.5  -69.9  -3.1
! 6.682 GHz  -1.1  -49.7  -49.4  -6.2
! 10.01 GHz  -2.7  -47.4  -47.5  -4.5
! 11.2 GHz  -2.8  -39.4  -39.6  -4.6
! 13.34 GHz  -2.0  -52.9  -53.0  -3.3
! 13.77 GHz  -1.0  -72.6  -68.9  -2.6
! 16.68 GHz  -1.5  -60.3  -60.5  7.2
! 17.6 GHz  -1.4  -69.9  -68.6  -3.4
! 18.55 GHz  -0.9  -41.5  -41.6  -23.8
! 19 GHz  -1.2  -38.5  -38.2  -6.2
! 20 GHz  -1.4  -33.5  -33.3  -2.5
