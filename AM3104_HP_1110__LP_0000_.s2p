!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -15.43 dB at 3.721 GHz (marker M1); lowest = -74.8 dB at 14.07 GHz (marker M2)
!   lowest |S11| = -16.7 dB at 3.558 GHz (marker M3), VSWR 1.34, Z = 37.6 + j2.84 ohm
!   |S11| at or under -10 dB: 2.939 GHz to 4.03 GHz (1.091 GHz wide, 31.3 % of centre)
!   |S22| runs from -19.7 to 13.6 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.408 GHz to 3.858 GHz only
!   S11 on the Smith chart (normalised r, x): 3.408 GHz: 0.69, -0.15; 3.508 GHz: 1.08, -0.31; 3.796 GHz: 0.79, -0.41; 3.858 GHz: 0.88, +0.53
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -64.4  -51.8  -0.1
! 1.447 GHz  -2.6  -47.0  -48.3  0.9
! 2.571 GHz  -5.0  -69.5  -68.4  -1.1
! 3.346 GHz  -12.4  -36.7  -36.8  -4.2
! 3.408 GHz  -13.8  -30.0  -30.1  -5.5
! 3.508 GHz  -16.4  -21.4  -21.5  -9.3
! 3.558 GHz  -16.7  -18.5  -18.6  -11.5
! 3.721 GHz  -13.3  -15.4  -15.5  -15.6
! 3.796 GHz  -11.9  -16.0  -16.0  -17.9
! 3.858 GHz  -11.1  -17.0  -17.0  -19.3
! 4.883 GHz  -4.4  -67.8  -68.4  -5.0
! 5.42 GHz  -2.3  -72.2  -71.6  -3.1
! 6.682 GHz  -0.8  -48.3  -48.6  -4.6
! 10.01 GHz  -2.6  -47.9  -48.0  -4.8
! 11.14 GHz  -2.7  -40.7  -40.9  -4.5
! 12.17 GHz  -2.5  -55.3  -57.6  -4.1
! 13.34 GHz  -1.9  -56.3  -56.6  -3.2
! 14.07 GHz  -1.3  -74.8  -71.2  -2.6
! 16.36 GHz  -1.8  -61.2  -61.5  -2.3
! 16.68 GHz  -1.5  -62.0  -61.9  7.1
! 18.66 GHz  -1.0  -40.3  -40.6  -19.4
! 20 GHz  -1.4  -33.8  -33.2  -2.6
