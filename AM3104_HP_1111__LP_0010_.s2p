!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -24.77 dB at 4.17 GHz (marker M1); lowest = -74.1 dB at 13.97 GHz (marker M2)
!   lowest |S11| = -14.3 dB at 3.858 GHz (marker M3), VSWR 1.48, Z = 44.5 + j17.8 ohm
!   |S11| at or under -10 dB: 3.197 GHz to 4.099 GHz (902.3 MHz wide, 24.7 % of centre)
!   |S22| runs from -23.8 to 13.7 dB; largest |S21 - S12| = 0.011
!   the Smith chart shows 3.758 GHz to 3.996 GHz only
!   S11 on the Smith chart (normalised r, x): 3.758 GHz: 1.58, -0.16; 3.808 GHz: 0.71, -0.20; 3.996 GHz: 0.72, +0.35
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -55.8  -53.1  0.0
! 1.584 GHz  -2.7  -39.1  -40.4  0.9
! 3.009 GHz  -7.0  -64.6  -62.6  -1.0
! 3.346 GHz  -12.0  -55.8  -55.6  -1.5
! 3.758 GHz  -12.7  -51.8  -51.5  -3.1
! 3.808 GHz  -13.7  -48.3  -48.3  -3.5
! 3.858 GHz  -14.3  -43.8  -44.1  -4.1
! 3.996 GHz  -12.0  -31.2  -31.2  -7.6
! 4.17 GHz  -9.5  -24.8  -24.8  -15.3
! 5.082 GHz  -4.6  -68.3  -67.3  -5.6
! 5.707 GHz  -2.2  -70.0  -69.9  -2.9
! 6.682 GHz  -1.0  -49.1  -49.0  -6.1
! 10.01 GHz  -2.6  -47.6  -47.9  -4.6
! 11.19 GHz  -2.8  -40.0  -40.1  -4.5
! 12.19 GHz  -2.5  -53.9  -56.0  -4.3
! 13.34 GHz  -2.0  -53.7  -53.7  -3.3
! 13.97 GHz  -0.9  -74.1  -71.3  -2.6
! 16.68 GHz  -1.5  -60.8  -59.9  7.2
! 17.66 GHz  -1.5  -69.5  -68.0  -3.7
! 18.55 GHz  -0.9  -42.1  -42.1  -23.8
! 19 GHz  -1.2  -38.5  -38.5  -6.2
! 20 GHz  -1.4  -33.5  -33.6  -2.5
