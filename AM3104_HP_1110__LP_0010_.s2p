!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -12.47 dB at 3.758 GHz (marker M1); lowest = -75.0 dB at 13.85 GHz (marker M2)
!   lowest |S11| = -18.3 dB at 3.633 GHz (marker M3), VSWR 1.28, Z = 60 - j8.84 ohm
!   |S11| at or under -10 dB: 3.052 GHz to 4.092 GHz (1.04 GHz wide, 29.1 % of centre)
!   |S22| runs from -19.8 to 13.6 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.433 GHz to 3.983 GHz only
!   S11 on the Smith chart (normalised r, x): 3.433 GHz: 0.68, +0.13; 3.533 GHz: 0.78, -0.16; 3.908 GHz: 1.58, -0.23; 3.983 GHz: 0.60, +0.19
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -53.4  -49.3  -0.1
! 1.584 GHz  -2.8  -47.6  -48.9  0.9
! 2.484 GHz  -4.3  -69.6  -71.2  -0.9
! 3.033 GHz  -9.6  -57.4  -58.2  -2.0
! 3.346 GHz  -13.0  -35.8  -35.9  -4.2
! 3.433 GHz  -13.7  -26.4  -26.4  -6.3
! 3.533 GHz  -16.4  -18.3  -18.4  -10.4
! 3.633 GHz  -18.3  -14.0  -14.1  -14.1
! 3.758 GHz  -16.3  -12.5  -12.5  -15.7
! 3.908 GHz  -12.4  -13.3  -13.3  -19.1
! 3.983 GHz  -11.3  -14.5  -14.5  -19.1
! 5.207 GHz  -3.7  -69.5  -77.3  -3.6
! 6.682 GHz  -1.0  -48.8  -48.9  -5.0
! 10.01 GHz  -2.7  -47.7  -47.6  -4.8
! 11.19 GHz  -2.8  -39.9  -40.0  -4.6
! 12.17 GHz  -2.5  -53.5  -55.4  -4.3
! 13.34 GHz  -2.0  -54.4  -54.1  -3.3
! 13.85 GHz  -0.7  -75.0  -70.5  -2.5
! 16.68 GHz  -1.5  -60.7  -61.4  7.1
! 17.24 GHz  -1.5  -63.6  -64.5  -3.5
! 18.66 GHz  -1.0  -40.5  -40.7  -19.5
! 20 GHz  -1.4  -33.7  -33.1  -2.6
