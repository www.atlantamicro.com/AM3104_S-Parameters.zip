!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -15.40 dB at 4.258 GHz (marker M1); lowest = -72.1 dB at 5.857 GHz (marker M2)
!   lowest |S11| = -15.8 dB at 4.045 GHz (marker M3), VSWR 1.38, Z = 69.2 + j0.982 ohm
!   |S11| at or under -10 dB: 3.442 GHz to 4.367 GHz (925.8 MHz wide, 23.7 % of centre)
!   |S22| runs from -22.2 to 13.6 dB; largest |S21 - S12| = 0.015
!   the Smith chart shows 3.896 GHz to 4.333 GHz only
!   S11 on the Smith chart (normalised r, x): 3.896 GHz: 1.59, +0.12; 3.996 GHz: 0.81, +0.25; 4.108 GHz: 0.73, -0.16; 4.208 GHz: 1.55, -0.28; 4.27 GHz: 0.56, -0.01; 4.333 GHz: 1.54, +0.57
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -53.0  -57.1  -0.1
! 1.747 GHz  -3.6  -39.1  -39.2  -0.6
! 3.046 GHz  -5.3  -66.2  -66.1  -1.1
! 3.346 GHz  -8.0  -58.2  -57.3  -1.5
! 3.896 GHz  -12.6  -36.0  -36.0  -4.7
! 3.996 GHz  -15.4  -25.3  -25.3  -7.8
! 4.045 GHz  -15.8  -21.3  -21.3  -9.8
! 4.108 GHz  -15.0  -17.8  -17.9  -12.0
! 4.208 GHz  -12.3  -15.5  -15.6  -14.7
! 4.258 GHz  -11.2  -15.4  -15.4  -15.7
! 4.27 GHz  -11.0  -15.4  -15.4  -15.9
! 4.333 GHz  -10.4  -15.9  -15.9  -16.2
! 5.857 GHz  -3.2  -72.1  -71.8  -3.2
! 6.682 GHz  -1.4  -51.7  -51.9  -6.5
! 10.01 GHz  -2.7  -47.2  -47.2  -4.4
! 11.33 GHz  -2.9  -37.3  -37.6  -5.0
! 13.34 GHz  -2.1  -47.1  -47.1  -3.6
! 13.99 GHz  -1.0  -68.5  -71.4  -2.8
! 16.68 GHz  -1.6  -60.2  -60.8  7.2
! 17.68 GHz  -1.6  -66.7  -67.8  -3.7
! 18.58 GHz  -0.9  -41.4  -41.6  -21.9
! 20 GHz  -1.4  -33.6  -33.2  -2.5
