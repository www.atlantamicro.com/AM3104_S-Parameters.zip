!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -13.41 dB at 4.283 GHz (marker M1); lowest = -75.7 dB at 5.857 GHz (marker M2)
!   lowest |S11| = -16.3 dB at 4.108 GHz (marker M3), VSWR 1.36, Z = 37.7 - j5.67 ohm
!   |S11| at or under -10 dB: 3.502 GHz to 4.596 GHz (1.094 GHz wide, 27 % of centre)
!   |S22| runs from -22.1 to 13.7 dB; largest |S21 - S12| = 0.019
!   the Smith chart shows 3.933 GHz to 4.433 GHz only
!   S11 on the Smith chart (normalised r, x): 3.933 GHz: 0.96, -0.46; 4.045 GHz: 1.38, -0.03; 4.183 GHz: 1.25, +0.30; 4.37 GHz: 1.33, -0.56; 4.433 GHz: 0.57, +0.13
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -47.9  -51.0  0.0
! 1.797 GHz  -3.6  -39.2  -39.2  -0.5
! 2.559 GHz  -4.1  -46.9  -46.6  -0.7
! 3.071 GHz  -5.1  -69.1  -66.8  -1.1
! 3.346 GHz  -7.0  -58.5  -58.6  -1.5
! 3.933 GHz  -12.8  -31.2  -31.2  -5.6
! 4.045 GHz  -15.8  -20.3  -20.3  -9.9
! 4.108 GHz  -16.3  -16.7  -16.7  -12.2
! 4.183 GHz  -15.2  -14.3  -14.3  -14.0
! 4.283 GHz  -12.8  -13.4  -13.4  -15.3
! 4.37 GHz  -11.4  -13.8  -13.8  -16.1
! 4.433 GHz  -10.8  -14.6  -14.6  -15.6
! 5.857 GHz  -3.9  -75.7  -71.3  -3.3
! 6.682 GHz  -1.6  -52.3  -52.4  -6.6
! 10.01 GHz  -2.7  -47.2  -47.0  -4.4
! 11.38 GHz  -2.9  -36.9  -37.1  -5.1
! 13.34 GHz  -2.1  -45.8  -46.0  -3.6
! 14.28 GHz  -1.4  -70.9  -78.5  -2.8
! 16.68 GHz  -1.6  -58.6  -59.7  7.2
! 17.69 GHz  -1.6  -68.3  -70.0  -3.7
! 18.58 GHz  -1.0  -41.7  -42.0  -21.7
! 20 GHz  -1.4  -33.6  -32.9  -2.5
