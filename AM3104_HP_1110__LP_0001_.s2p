!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -13.74 dB at 3.746 GHz (marker M1); lowest = -74.3 dB at 13.85 GHz (marker M2)
!   lowest |S11| = -17.6 dB at 3.596 GHz (marker M3), VSWR 1.30, Z = 54.1 + j13.2 ohm
!   |S11| at or under -10 dB: 3.001 GHz to 4.033 GHz (1.032 GHz wide, 29.4 % of centre)
!   |S22| runs from -19.7 to 13.6 dB; largest |S21 - S12| = 0.012
!   the Smith chart shows 3.421 GHz to 3.921 GHz only
!   S11 on the Smith chart (normalised r, x): 3.421 GHz: 0.65, -0.01; 3.521 GHz: 0.90, -0.27; 3.771 GHz: 1.43, -0.26; 3.858 GHz: 0.79, +0.42; 3.921 GHz: 1.10, -0.61
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -53.0  -52.2  0.0
! 1.572 GHz  -3.0  -47.5  -48.9  0.8
! 2.471 GHz  -4.3  -69.9  -67.2  -0.9
! 3.009 GHz  -10.2  -57.3  -58.3  -1.9
! 3.346 GHz  -12.4  -36.1  -36.2  -4.2
! 3.421 GHz  -13.6  -28.1  -28.1  -5.9
! 3.521 GHz  -16.5  -19.7  -19.7  -9.9
! 3.596 GHz  -17.6  -15.9  -16.0  -13.0
! 3.746 GHz  -14.4  -13.7  -13.8  -15.7
! 3.771 GHz  -13.7  -13.8  -13.9  -16.1
! 3.858 GHz  -12.0  -14.6  -14.6  -19.1
! 3.921 GHz  -11.0  -15.7  -15.7  -19.3
! 4.97 GHz  -4.6  -69.9  -67.8  -4.7
! 5.432 GHz  -2.6  -71.4  -72.5  -3.1
! 6.682 GHz  -0.9  -48.9  -48.9  -4.8
! 10.01 GHz  -2.6  -47.8  -47.5  -4.8
! 11.17 GHz  -2.7  -40.2  -40.4  -4.6
! 13.34 GHz  -1.9  -55.4  -55.6  -3.2
! 13.85 GHz  -0.7  -74.3  -70.6  -2.5
! 16.68 GHz  -1.5  -60.4  -61.8  7.1
! 18.66 GHz  -1.0  -40.2  -40.4  -19.4
! 20 GHz  -1.4  -33.8  -33.1  -2.6
