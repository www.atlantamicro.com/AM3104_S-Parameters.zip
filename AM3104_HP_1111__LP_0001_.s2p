!Created with skrf (http://scikit-rf.org).
# Hz S RI R 50.0
!freq ReS11 ImS11 ReS21 ImS21 ReS12 ImS12 ReS22 ImS22
! Worked out from all points (weakly coupled two-port):
!   1601 points, 10 MHz to 20 GHz, reference 50 ohm
!   highest |S21| = -28.53 dB at 4.158 GHz (marker M1); lowest = -74.3 dB at 13.82 GHz (marker M2)
!   lowest |S11| = -13.7 dB at 3.808 GHz (marker M3), VSWR 1.52, Z = 35.2 - j9.87 ohm
!   |S11| at or under -10 dB: 3.122 GHz to 4.043 GHz (921.3 MHz wide, 25.7 % of centre)
!   |S22| runs from -24.2 to 13.7 dB; largest |S21 - S12| = 0.011
!   the Smith chart shows 3.721 GHz to 3.921 GHz only
!   S11 on the Smith chart (normalised r, x): 3.721 GHz: 0.95, +0.45; 3.808 GHz: 0.70, -0.20; 3.846 GHz: 0.74, +0.26; 3.896 GHz: 1.62, +0.00; 3.921 GHz: 1.11, -0.54
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -57.4  -48.6  0.0
! 1.584 GHz  -2.9  -39.0  -40.4  0.9
! 3.009 GHz  -7.9  -65.0  -63.0  -1.0
! 3.346 GHz  -11.7  -55.6  -55.7  -1.5
! 3.721 GHz  -12.8  -55.9  -54.6  -2.8
! 3.808 GHz  -13.7  -50.8  -50.3  -3.5
! 3.846 GHz  -13.5  -47.5  -47.3  -3.9
! 3.896 GHz  -12.6  -42.8  -42.9  -4.7
! 3.921 GHz  -12.0  -40.5  -40.5  -5.3
! 4.158 GHz  -9.4  -28.5  -28.6  -15.1
! 4.958 GHz  -4.7  -67.9  -66.8  -7.1
! 5.67 GHz  -2.0  -70.7  -68.2  -2.9
! 6.682 GHz  -0.9  -48.8  -49.1  -5.9
! 10.01 GHz  -2.7  -47.8  -47.8  -4.6
! 11.15 GHz  -2.7  -40.3  -40.5  -4.5
! 13.34 GHz  -2.0  -54.9  -54.9  -3.3
! 13.82 GHz  -0.8  -74.3  -70.7  -2.6
! 16.68 GHz  -1.5  -60.7  -61.5  7.2
! 17.61 GHz  -1.4  -68.2  -66.2  -3.5
! 18.55 GHz  -0.9  -41.7  -41.6  -24.2
! 19 GHz  -1.1  -38.3  -38.3  -6.3
! 20 GHz  -1.4  -33.7  -33.2  -2.5
